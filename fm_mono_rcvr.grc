options:
  parameters:
    author: Onno VK6FLAB
    description: Based on the work by John E. Post
    generate_options: qt_gui
    id: fm_mono_rcvr
    output_language: python
    title: FM Mono Receiver
  states: {}

blocks:
- name: automatic_dc_removal
  id: variable
  parameters:
    comment: |-
      Some Soapy devices support
      automatic DC removal, set
      to "True" if your device does.
    value: 'False'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Frequency
    start: 88.1e6
    step: '0.2'
    stop: 107.9e6
    value: 99.3e6
    widget: eng_slider
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Volume
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: tau
  id: variable
  parameters:
    comment: |-
      The USA uses "75e-6",
      the rest of the world
      uses "50e-6".
    value: '50e-6'
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate/50
    tau: tau
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: 240e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '5'
    gain: gain
    samp_rate: samp_rate/10
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,5,2
    label0: RF Spectrum
    label1: Baseband Spectrum
    label2: Audio Spectrum
    num_tabs: '3'
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    center_freq0: freq
    dc_removal0: automatic_dc_removal
    driver: remote
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: wxgui_fftsink2_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@0
    legend: 'False'
    type: complex
  states: {}
- name: wxgui_fftsink2_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/50
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: qtgui_tab_widget_0@2
    legend: 'False'
    type: float
    wintype: window.WIN_HAMMING
  states: {}
- name: wxgui_fftsink2_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/10
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: qtgui_tab_widget_0@1
    legend: 'False'
    type: float
    wintype: window.WIN_HAMMING
    ymin: '-240'
  states: {}

connections:
- [analog_fm_deemph_0, '0', audio_sink_0, '0']
- [analog_fm_deemph_0, '0', wxgui_fftsink2_1, '0']
- [analog_wfm_rcv_0, '0', low_pass_filter_1, '0']
- [analog_wfm_rcv_0, '0', wxgui_fftsink2_2, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_1, '0', analog_fm_deemph_0, '0']
- [soapy_custom_source_0, '0', low_pass_filter_0, '0']
- [soapy_custom_source_0, '0', wxgui_fftsink2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
